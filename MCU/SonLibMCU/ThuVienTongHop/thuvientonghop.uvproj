# Keil uVision project thuvientonghop.uvproj, settings and files
target Root (MCS-51)
  device: AT89S52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(33000000) MODAT2
  output: thuvientonghop
  c flags: Optimize=8 SizeSpeed=1
  group Code
    ./: 24c3264.c backup.c bell.c caidatthietbi.c checktimeout.c crc.c crc8.c crc16.c delay.c digi2text.c i2c.c init_tiin.c init_time2.c interup.c ir_getkey.c lcd.c main.c moduleserial.c mudulesim.c outputdevice.c retiao.c sulydulieu.c sulymangbit.c sulythietbi.c sulythoigian.c sylymangbit(nguoc).c testfuntion.c disnuled.c
  group Header
    ./: 24c3264.h 89s52_bk.h allfuntion.h AT89X52.H bell.h caidatthietbi.h checktimeout.h crc.h crc8.h crc16.h delay.h digi2text.h i2c.h init_tiin.h init_time2.h iodevice.h ir_getkey.h lcd.h Number2Text.h outputdevice.h P89V51Rx2.H retiao.h string(hChuThich).h sulydulieu.h sulymangbit.h sulythietbi.h sulythoigian.h testfuntion.h typedef.h disnuled.h thanhsonchip.h
